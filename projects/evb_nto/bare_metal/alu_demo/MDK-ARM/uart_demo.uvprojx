# Keil uVision project uart_demo.uvprojx, settings and files
target uart_demo (6220000::V6.22::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: uart_demo
  AfterMake: .\cmd.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: CONFIG_SOC_DARIC_NTO_A=1,CONFIG_SUPPORT_800MFREQ,HAL_UART_MODULE_ENABLED=1,HAL_UDMA_MODULE_ENABLED=1,HAL_NVIC_MODULE_ENABLED=1,HAL_IFRAMMGR_MODULE_ENABLED=1,HAL_PINMAP_MODULE_ENABLED,HAL_GPIO_MODULE_ENABLED,CONFIG_PMIC_I2C_ID=1,CONFIG_PMIC_I2C_SPEED=100,CONFIG_PMIC_I2C_ADDR=0x34,HAL_ATIMER_MODULE_ENABLED
  c include: ..\inc;..\..\..\..\..\drivers\Inc;..\..\..\..\..\drivers\Inc\arch\arm;..\..\..\..\..\drivers\Tlsf\Inc;..\..\..\..\..\bsp\include;..\..\..\..\..\bsp\Components\Common;..\..\..\..\..\bsp\Components\TG28;..\..\..\..\..\middleware\crossbar\crypto;..\..\..\..\..\drivers\Inc\sce
  memory RVCT4: ROM 0x60000000 size 0x300000
  memory RVCT9: RAM 0x61000000 size 0x100000
  memory RVCT10: RAM 0x61100000 size 0x100000
  scatter file: .\scatter\uart_demo.sct
  group main
    ../src/: main.c syscalls.c
    ../../../../../drivers/Tlsf/Src/: daric_tlsf.c
  group drivers
    ../../../../../drivers/Src/: daric_hal.c daric_hal_atimer.c daric_ifram.c daric_hal_gpio.c daric_hal_nvic.c
    ../../../../../drivers/Src/sce/: alu.c bn_util.c aes.c hash.c pke_curve.c pke_rsa.c sdma.c trng.c
  group device
    ../src/: startup_daric.c
    ../../../../../drivers/Src/arch/arm/: system_daric.c
  group ll_api
    ../../../../../middleware/crossbar/crypto/: ll_api.c
software components: CMSIS:CORE 5.6.0
